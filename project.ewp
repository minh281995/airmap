# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\code; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3\DeviceSupport; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3\DeviceSupport\ST; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3\DeviceSupport\ST\STM32F10x; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3\DeviceSupport\ST\STM32F10x\startup; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\CM3\DeviceSupport\ST\STM32F10x\startup\iar; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\inc; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\driver\src; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\library; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\library; E:\AIRMAP PROJECT\airmap_STM32F1-V1\airmap_STM32F1\library
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    driver/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Code
    code/: control.c main.c state.c stm32f10x_it.c
  group Driver
    driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    driver/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Library
    library/: communication.c debug.c device.c hardware.c sensor.c
